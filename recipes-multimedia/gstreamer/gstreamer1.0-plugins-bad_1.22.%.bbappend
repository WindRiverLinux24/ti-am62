COMPATIBLE_MACHINE:ti-am62 = "ti-am62"

PACKAGECONFIG:append:pn-gstreamer1.0-plugins-bad:ti-am62 = ' kms'
