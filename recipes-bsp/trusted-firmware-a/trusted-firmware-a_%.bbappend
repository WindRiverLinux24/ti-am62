PV:ti-am62 = "2.10+git"
SRCREV_tfa:ti-am62 = "00f1ec6b8740ccd403e641131e294aabacf2a48b"
LIC_FILES_CHKSUM:ti-am62 = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"
