COMPATIBLE_MACHINE:ti-am62 = "ti-am62"