require linux-yocto-ti-am62.inc

KBRANCH:ti-am62  = "v6.1/standard/ti-sdk-6.1/ti-j7xxx"

