require linux-yocto-ti-am62.inc

KBRANCH:ti-am62  = "v6.6/standard/ti-sdk-6.6/ti-soc"

