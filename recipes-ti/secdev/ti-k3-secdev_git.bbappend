COMPATIBLE_HOST:ti-am62 = "${HOST_SYS}"
COMPATIBLE_MACHINE:ti-am62 = "ti-am62"

DEPENDS:append:ti-am62 = " openssl-native"
